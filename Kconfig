## Kconfig
```kconfig
menuconfig EXAMPLES_GPV
	bool "gpv"
	default n
	---help---
		Enable support for gpv
```
